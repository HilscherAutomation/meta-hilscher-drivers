require driver_dev_version.inc

LIC_FILES_CHKSUM = "file://Toolkit/LICENSE.md;md5=a11facdeafb2bdb3b750ce17f15c59e8"

require libcifx.inc
