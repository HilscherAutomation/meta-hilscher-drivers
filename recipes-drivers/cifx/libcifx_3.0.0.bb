
require driver_version.inc
LIC_FILES_CHKSUM = "file://LICENSE;md5=eae965cb67f143ba6a9eb017ac821601 \
                    file://Toolkit/HilscherSLA.pdf;md5=1d3864f430ae2bf421d0d76e91a3dbb8"
NO_GENERIC_LICENSE[HilscherSLA] = "Toolkit/HilscherSLA.pdf"
require libcifx.inc
