
require driver_version.inc

S .= "/cifx_m2"

require cifx-ax99100.inc
