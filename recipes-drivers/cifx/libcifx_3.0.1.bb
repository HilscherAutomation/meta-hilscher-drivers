
require driver_version.inc

LIC_FILES_CHKSUM = "file://Toolkit/LICENSE.md;md5=b887653049e6302650eed7ce602b351e"

SRC_URI += " file://0001-If-possible-allow-use-of-git-describe-version-scheme.patch;patchdir=../ "

require libcifx.inc
