
require driver_dev_version.inc

S .= "/cifx_ax99100"

require cifx-ax99100.inc
